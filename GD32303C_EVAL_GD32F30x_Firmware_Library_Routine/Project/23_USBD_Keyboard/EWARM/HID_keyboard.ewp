# IAR project HID_keyboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F30X_HD
  ICCARM.CCIncludePath2: ..\..\..\Library\Firmware\CMSIS\GD\GD32F30x\Include; ..\..\..\Library\Firmware\GD32F30x_standard_peripheral\Include; ..\..\..\Library\Firmware\GD32F30x_usbd_driver\Include; ..\..\..\Library\Utilities; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HID_keyboard.srec
  ILINK.IlinkOutputFile: HID_Keyboard.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F303xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32f30x_it.c hid_core.c main.c
  group CMSIS
    ../../../Library/Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Doc
    ../: readme.txt
  group GD32F30x_EVAL
    ../../../Library/Utilities/: gd32f303c_eval.c
  group GD32F30x_Peripherals
    ../../../Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c
  group Startup
    ../../../Library/Firmware/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_hd.s
  group USB_Drivers
    ../../../Library/Firmware/GD32F30x_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
